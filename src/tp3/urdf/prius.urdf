Commit message: Aenderung => Fahrzeug bewegt sich relativ im Bild

File: src/tp3/urdf/prius.urdf (robot description, URDF)
Before this commit: robot prius, 29 links, 28 joints
Joints:
- joint base_link_connection: axis 0 0 0 -> 1 0 0
